require optee-examples.inc

LIC_FILES_CHKSUM = "file://LICENSE;md5=cd95ab417e23b94f381dafc453d70c30"
SRCREV = "${AUTOREV}"

COMPATIBLE_MACHINE = "adsp-sc598-som-ezkit"
