require optee-test.inc

LIC_FILES_CHKSUM = "file://${S}/LICENSE.md;md5=a8fa504109e4cd7ea575bc49ea4be560"
SRCREV = "${AUTOREV}"

COMPATIBLE_MACHINE = "(adsp-sc598-som-ezkit)"
