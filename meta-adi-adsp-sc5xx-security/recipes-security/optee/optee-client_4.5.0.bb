
include optee-client.inc

SRCREV = "${AUTOREV}"

LIC_FILES_CHKSUM = "file://LICENSE;md5=69663ab153298557a59c67a60a743e5b"
COMPATIBLE_MACHINE = "adsp-sc598-som-ezkit"
