
include optee-client.inc

LIC_FILES_CHKSUM = "file://LICENSE;md5=69663ab153298557a59c67a60a743e5b"
SRCREV = "06db73b3f3fdb8d23eceaedbc46c49c0b45fd1e2"

COMPATIBLE_MACHINE = "adsp-sc598-som-ezkit"
