require optee-examples.inc

SRCREV = "65fc74309e12189ad5b6ce3ffec37c8011088a5a"

COMPATIBLE_MACHINE = "adsp-sc598-som-ezkit"
