inherit adsp-signed-fit
